# Keil uVision project BK4802Nstc8OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F1K08S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: BK4802Nstc8OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: bk4802noledstc8.c
